# Keil uVision project MX.uvprojx, settings and files
target MX (6240000::V6.24::ARMCLANG)
  device: STM32H503RBTx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.2.1.1
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x08000000-0x801FFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: MX +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H503xx
  c include: ../Core/Inc;..\MCUDrivers\STM32H5xx_HAL_Driver\Inc;..\MCUDrivers\STM32H5xx_HAL_Driver\Inc\Legacy;..\MCUDrivers\CMSIS\Device\ST\STM32H5xx\Include;..\MCUDrivers\CMSIS\Include;..\UserApplication\Inc;..\UserApplication\Application\Inc;..\UserApplication\Mcal\Inc;..\UserApplication\Bsw\Inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32h503xx.s
  group Application/User/Core
    ../Core/Src/: main.c
  group Drivers/STM32H5xx_HAL_Driver
    ../MCUDrivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal_cortex.c stm32h5xx_hal_icache.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal.c stm32h5xx_hal_exti.c
    ../MCuDrivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal_gpio.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h5xx.c
  group UserApplication/Mcal
    ../UserApplication/Mcal/Src/: Mcal.c Mcal_Lcfg.c
  group UserApplication/App
    ../UserApplication/Application/Src/: App.c
  group UserApplication/Bsw
    ../UserApplication/Bsw/Src/: Bsw.c
software components: CMSIS:CORE 4.3.0
